options:
  parameters:
    description: Urban Data demo flowgraph -- ZMQ source, Fake AI Analyzer, Fake AI Processor, ZMQ stub sink
    generate_options: no_gui
    id: urban_data
    output_language: python
    title: Urban Data Demo Flowgraph
  states: {}

blocks:
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import os, sys

      URBAN_DATA_ROOT = os.path.join(os.path.expanduser("~"), "github", "urban_data")

      sys.path.insert(0, URBAN_DATA_ROOT)

      import pmt
      from gnuradio import gr
      from common.ai_analyzer import AnalyzerLogic

      import numpy as np


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name="ai_analyzer", in_sig=[], out_sig=[])
              self.logic = AnalyzerLogic()
              self.message_port_register_in(pmt.intern("sources"))
              self.message_port_register_out(pmt.intern("events"))
              self.set_msg_handler(pmt.intern("sources"), self.handle_msg)

          def handle_msg(self, msg):
              blob = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              out = self.logic.analyze(blob)
              out_pmt = pmt.init_u8vector(len(out), list(out))
              self.message_port_pub(pmt.intern("events"), pmt.cons(pmt.PMT_NIL, out_pmt))
    alias: AI_Analyzer
    comment: 'Step 2: Source PDU -> Event PDU (common/ai_analyzer.py)'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import os, sys

      URBAN_DATA_ROOT = os.path.join(os.path.expanduser("~"), "github", "urban_data")
      DEFAULT_SCENARIO_PATH = os.path.join(URBAN_DATA_ROOT, "scenarios", "01_all_ok", "scenario.json")

      sys.path.insert(0, URBAN_DATA_ROOT)

      import pmt
      from gnuradio import gr
      from common.ai_processor import ProcessorLogic


      class blk(gr.basic_block):
          def __init__(self, scenario_path=DEFAULT_SCENARIO_PATH):
              gr.basic_block.__init__(self, name="ai_processor", in_sig=[], out_sig=[])
              self.logic = ProcessorLogic(scenario_path)
              self.message_port_register_in(pmt.intern("events"))
              self.message_port_register_out(pmt.intern("agent_trigger"))
              self.set_msg_handler(pmt.intern("events"), self.handle_msg)

          def handle_msg(self, msg):
              blob = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              result = self.logic.handle(blob)
              for t in result["agent_triggers"]:
                  t_pmt = pmt.init_u8vector(len(t), list(t))
                  self.message_port_pub(pmt.intern("agent_trigger"), pmt.cons(pmt.PMT_NIL, t_pmt))
    comment: 'Step 3: buffers by tag_id, synthesizes group events (common/ai_processor.py)'
    scenario_path: '''/home/radiolab9/github/urban_data/scenarios/01_all_ok/scenario.json'''
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |-
      import os, sys

      URBAN_DATA_ROOT = os.path.join(os.path.expanduser("~"), "github", "urban_data")
      DEFAULT_SCENARIO_PATH = os.path.join(URBAN_DATA_ROOT, "scenarios", "01_all_ok", "scenario.json")

      sys.path.insert(0, URBAN_DATA_ROOT)

      import pmt
      from gnuradio import gr
      from common.ai_processor import ProcessorLogic


      class blk(gr.basic_block):
          def __init__(self, scenario_path=DEFAULT_SCENARIO_PATH):
              gr.basic_block.__init__(self, name="debug_controller", in_sig=[], out_sig=[])
              self.logic = ProcessorLogic(scenario_path)
              self.message_port_register_in(pmt.intern("events"))
              self.message_port_register_out(pmt.intern("print_pdu"))
              self.message_port_register_out(pmt.intern("store"))
              self.message_port_register_out(pmt.intern("print"))        
              self.message_port_register_out(pmt.intern("log"))
              self.set_msg_handler(pmt.intern("events"), self.handle_msg)

          def handle_msg(self, msg):
              blob = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              result = self.logic.handle(blob)
              for t in result["agent_triggers"]:
                  t_pmt = pmt.init_u8vector(len(t), list(t))
                  self.message_port_pub(pmt.intern("agent_trigger"), pmt.cons(pmt.PMT_NIL, t_pmt))
    scenario_path: '''/home/ailab9/github/urban_data/scenarios/01_all_ok/scenario.json'''
  states: {}
- name: message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: zmq_sink
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5557
    comment: Stub sink until Step 4 UI exists -- subscribe here to process agent workflow
    timeout: '100'
  states: {}
- name: zmq_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5556
    comment: Stub sink until Step 4 UI exists -- subscribe here to watch live Event PDUs
    timeout: '100'
  states: {}
- name: zmq_source
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    comment: Connects to scenario_controller's ZMQ PUB (which binds)
    timeout: '100'
  states: {}

connections:
- [epy_block_0, events, epy_block_1, events]
- [epy_block_0, events, epy_block_2, events]
- [epy_block_0, events, zmq_sink_0, in]
- [epy_block_1, agent_trigger, zmq_sink, in]
- [epy_block_2, log, message_debug_0, log]
- [epy_block_2, print, message_debug_0, print]
- [epy_block_2, print_pdu, message_debug_0, print_pdu]
- [epy_block_2, store, message_debug_0, store]
- [zmq_source, out, epy_block_0, sources]

metadata:
  file_format: 1
  grc_version: 3.10.9.2

options:
  parameters:
    description: Urban Data demo flowgraph -- ZMQ source, Fake AI Analyzer, Fake AI Processor, ZMQ stub sink
    generate_options: no_gui
    id: urban_data
    output_language: python
    title: Urban Data Demo Flowgraph
  states: {}

blocks:
- name: zmq_source
  id: zeromq_sub_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    comment: Connects to scenario_controller's ZMQ PUB (which binds)
    timeout: '100'
  states: {}
- name: fake_ai_analyzer
  id: epy_block
  parameters:
    _source_code: |-
      import os, sys
      sys.path.insert(0, os.path.join(os.path.dirname(os.path.abspath(__file__)), os.pardir))

      import pmt
      from gnuradio import gr
      from common.ai_analyzer import AnalyzerLogic


      class blk(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self, name="fake_ai_analyzer", in_sig=[], out_sig=[])
              self.logic = AnalyzerLogic()
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              blob = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              out = self.logic.analyze(blob)
              out_pmt = pmt.init_u8vector(len(out), list(out))
              self.message_port_pub(pmt.intern("out"), pmt.cons(pmt.PMT_NIL, out_pmt))
    comment: 'Step 2: Source PDU -> Event PDU (common/ai_analyzer.py)'
  states: {}
- name: fake_ai_processor
  id: epy_block
  parameters:
    _source_code: |-
      import os, sys
      sys.path.insert(0, os.path.join(os.path.dirname(os.path.abspath(__file__)), os.pardir))

      import pmt
      from gnuradio import gr
      from common.ai_processor import ProcessorLogic


      class blk(gr.basic_block):
          def __init__(self, scenario_path="scenarios/01_all_ok/scenario.json"):
              gr.basic_block.__init__(self, name="fake_ai_processor", in_sig=[], out_sig=[])
              self.logic = ProcessorLogic(scenario_path)
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("events"))
              self.message_port_register_out(pmt.intern("agent_trigger"))
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)

          def handle_msg(self, msg):
              blob = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              result = self.logic.handle(blob)
              for e in result["events"]:
                  e_pmt = pmt.init_u8vector(len(e), list(e))
                  self.message_port_pub(pmt.intern("events"), pmt.cons(pmt.PMT_NIL, e_pmt))
              for t in result["agent_triggers"]:
                  t_pmt = pmt.init_u8vector(len(t), list(t))
                  self.message_port_pub(pmt.intern("agent_trigger"), pmt.cons(pmt.PMT_NIL, t_pmt))
    comment: 'Step 3: buffers by tag_id, synthesizes group events (common/ai_processor.py)'
    scenario_path: '"scenarios/01_all_ok/scenario.json"'
  states: {}
- name: zmq_sink
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5556
    comment: Stub sink until Step 4 UI exists -- subscribe here to watch live Event PDUs
    timeout: '100'
  states: {}
- name: message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}

connections:
- [zmq_source, out, fake_ai_analyzer, in]
- [fake_ai_analyzer, out, fake_ai_processor, in]
- [fake_ai_processor, events, zmq_sink, in]
- [fake_ai_processor, events, message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
